# Keil uVision project test01.uvproj, settings and files
target test01 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test12 +hex
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\USER;.\SYSTEM\delay;.\CORE;.\HARDWARE\DHT11;.\STM32F10x_FWLib\inc;.\HARDWARE\KEY;.\HARDWARE\LED;.\HARDWARE\USART3;.\HARDWARE\TIMER;.\HARDWARE\DL_LN3X;.\SYSTEM\sys;.\SYSTEM\usart;.\STM32F10x_FWLib\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ./CORE/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s
  group USER
    ./USER/: main.c stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
  group SYSTEM
    ./SYSTEM/usart/: usart.c usart.h
    ./SYSTEM/sys/: lee.h package.h sys.c sys.h
    ./SYSTEM/delay/: delay.c delay.h
  group HARDWARE
    ./HARDWARE/DL_LN3X/: DL_LN3X.h DL_LN3X_recv.c DL_LN3X_send.c
    ./HARDWARE/KEY/: led.c led.h
    ./HARDWARE/TIMER/: timer.c timer.h
    ./HARDWARE/USART3/: usart3.c usart3.h
  group STM32F10x_FWLib
    ./STM32F10x_FWLib/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
