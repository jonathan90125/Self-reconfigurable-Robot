# Keil uVision project USART.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: USART +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\DL_LN3X;..\HARDWARE\TIMER;..\HARDWARE\USART3;..\HARDWARE\DHT11;..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/DL_LN3X/: DL_LN3X_recv.c DL_LN3X_send.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/TIMER/: timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c
  group README
    ../: README.TXT
